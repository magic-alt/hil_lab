# Keil uVision project hil_pwm_stimulus.uvprojx, settings and files
target 20k_50_600ns (6180000::V6.18::ARMCLANG)
  device: STM32F429ZITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: IRAM(0x20000000,0x00030000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(180000000) ELITTLE
  output: hil_pwm_20k_50_600ns +hex
  c flags: Optim=2 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=3
  c define: PWM_FREQUENCY_HZ=20000UL,PWM_DUTY_PERMILLE=500UL,PWM_DEADTIME_NS=600UL,PWM_PROFILE_ID=1UL
  c misc: -ffunction-sections -fdata-sections
  c include: ..\Inc
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\stm32f429_flash.sct
  link misc: --remove
  group Application
    ../Src/: main.c system_stm32f4xx.c
  group Startup
    ../Startup/: startup_stm32f429xx.s
  group Headers
    ../Inc/: pwm_profile.h stm32f429_regs.h
target 20k_50_700ns (6180000::V6.18::ARMCLANG)
  device: STM32F429ZITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: as above
  output: hil_pwm_20k_50_700ns +hex
  c flags: Optim=2 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=3
  c define: PWM_FREQUENCY_HZ=20000UL,PWM_DUTY_PERMILLE=500UL,PWM_DEADTIME_NS=700UL,PWM_PROFILE_ID=2UL
  c misc: -ffunction-sections -fdata-sections
  c include: ..\Inc
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\stm32f429_flash.sct
  link misc: --remove
target 20k_50_800ns (6180000::V6.18::ARMCLANG)
  device: STM32F429ZITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: as above
  output: hil_pwm_20k_50_800ns +hex
  c flags: Optim=2 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=3
  c define: PWM_FREQUENCY_HZ=20000UL,PWM_DUTY_PERMILLE=500UL,PWM_DEADTIME_NS=800UL,PWM_PROFILE_ID=3UL
  c misc: -ffunction-sections -fdata-sections
  c include: ..\Inc
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\stm32f429_flash.sct
  link misc: --remove
target 20k_5_700ns (6180000::V6.18::ARMCLANG)
  device: STM32F429ZITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: as above
  output: hil_pwm_20k_5_700ns +hex
  c flags: Optim=2 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=3
  c define: PWM_FREQUENCY_HZ=20000UL,PWM_DUTY_PERMILLE=50UL,PWM_DEADTIME_NS=700UL,PWM_PROFILE_ID=4UL
  c misc: -ffunction-sections -fdata-sections
  c include: ..\Inc
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\stm32f429_flash.sct
  link misc: --remove
target 20k_25_700ns (6180000::V6.18::ARMCLANG)
  device: STM32F429ZITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: as above
  output: hil_pwm_20k_25_700ns +hex
  c flags: Optim=2 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=3
  c define: PWM_FREQUENCY_HZ=20000UL,PWM_DUTY_PERMILLE=250UL,PWM_DEADTIME_NS=700UL,PWM_PROFILE_ID=5UL
  c misc: -ffunction-sections -fdata-sections
  c include: ..\Inc
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\stm32f429_flash.sct
  link misc: --remove
target 20k_75_700ns (6180000::V6.18::ARMCLANG)
  device: STM32F429ZITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: as above
  output: hil_pwm_20k_75_700ns +hex
  c flags: Optim=2 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=3
  c define: PWM_FREQUENCY_HZ=20000UL,PWM_DUTY_PERMILLE=750UL,PWM_DEADTIME_NS=700UL,PWM_PROFILE_ID=6UL
  c misc: -ffunction-sections -fdata-sections
  c include: ..\Inc
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\stm32f429_flash.sct
  link misc: --remove
target 20k_95_700ns (6180000::V6.18::ARMCLANG)
  device: STM32F429ZITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: as above
  output: hil_pwm_20k_95_700ns +hex
  c flags: Optim=2 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=3
  c define: PWM_FREQUENCY_HZ=20000UL,PWM_DUTY_PERMILLE=950UL,PWM_DEADTIME_NS=700UL,PWM_PROFILE_ID=7UL
  c misc: -ffunction-sections -fdata-sections
  c include: ..\Inc
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\stm32f429_flash.sct
  link misc: --remove
