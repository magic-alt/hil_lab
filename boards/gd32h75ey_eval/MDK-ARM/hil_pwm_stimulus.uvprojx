# Keil uVision project hil_pwm_stimulus.uvprojx, settings and files
target 20k_50_600ns (6180000::V6.18::ARMCLANG)
  device: GD32H75EYMJ6 GigaDevice
  pack: GigaDevice.GD32H75E_DFP.1.4.0
  cpu: IRAM(0x24000000,0x000D0000) IRAM2(0x00000000,0x00010000) IROM(0x08000000,0x03C0000) XRAM(0x20000000,0x00020000) XRAM2(0x30000000,0x00004000) XRAM3(0x30004000,0x00004000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(600000000) ELITTLE
  output: hil_pwm_20k_50_600ns +hex
  c flags: Optim=2 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=3
  c define: USE_STDPERIPH_DRIVER,GD32H75E,PWM_FREQUENCY_HZ=20000UL,PWM_DUTY_PERMILLE=500UL,PWM_DEADTIME_NS=600UL,PWM_PROFILE_ID=1UL
  c misc: -ffunction-sections -fdata-sections
  c include: ..\Inc;..\Vendor\CMSIS;..\Vendor\CMSIS\GD\GD32H75E\Include;..\Vendor\GD32H75E_standard_peripheral\Include
  library: MicroLIB
  link misc: --remove
  group Application
    ../Src/: main.c
    ../Inc/: pwm_profile.h gd32h75e_libopt.h
  group CMSIS Device
    ../Vendor/CMSIS/GD/GD32H75E/Source/ARM/: startup_gd32h75e.s
    ../Vendor/CMSIS/GD/GD32H75E/Source/: system_gd32h75e.c
  group GD32H75E SPL
    ../Vendor/GD32H75E_standard_peripheral/Source/: gd32h75e_gpio.c gd32h75e_rcu.c gd32h75e_timer.c
target 20k_50_700ns (6180000::V6.18::ARMCLANG)
  device: GD32H75EYMJ6 GigaDevice
  pack: GigaDevice.GD32H75E_DFP.1.4.0
  cpu: as above
  output: hil_pwm_20k_50_700ns +hex
  c flags: Optim=2 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=3
  c define: USE_STDPERIPH_DRIVER,GD32H75E,PWM_FREQUENCY_HZ=20000UL,PWM_DUTY_PERMILLE=500UL,PWM_DEADTIME_NS=700UL,PWM_PROFILE_ID=2UL
  c misc: -ffunction-sections -fdata-sections
  c include: as above
  library: MicroLIB
  link misc: --remove
target 20k_50_800ns (6180000::V6.18::ARMCLANG)
  device: GD32H75EYMJ6 GigaDevice
  pack: GigaDevice.GD32H75E_DFP.1.4.0
  cpu: as above
  output: hil_pwm_20k_50_800ns +hex
  c flags: Optim=2 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=3
  c define: USE_STDPERIPH_DRIVER,GD32H75E,PWM_FREQUENCY_HZ=20000UL,PWM_DUTY_PERMILLE=500UL,PWM_DEADTIME_NS=800UL,PWM_PROFILE_ID=3UL
  c misc: -ffunction-sections -fdata-sections
  c include: as above
  library: MicroLIB
  link misc: --remove
target 20k_5_700ns (6180000::V6.18::ARMCLANG)
  device: GD32H75EYMJ6 GigaDevice
  pack: GigaDevice.GD32H75E_DFP.1.4.0
  cpu: as above
  output: hil_pwm_20k_5_700ns +hex
  c flags: Optim=2 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=3
  c define: USE_STDPERIPH_DRIVER,GD32H75E,PWM_FREQUENCY_HZ=20000UL,PWM_DUTY_PERMILLE=50UL,PWM_DEADTIME_NS=700UL,PWM_PROFILE_ID=4UL
  c misc: -ffunction-sections -fdata-sections
  c include: as above
  library: MicroLIB
  link misc: --remove
target 20k_25_700ns (6180000::V6.18::ARMCLANG)
  device: GD32H75EYMJ6 GigaDevice
  pack: GigaDevice.GD32H75E_DFP.1.4.0
  cpu: as above
  output: hil_pwm_20k_25_700ns +hex
  c flags: Optim=2 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=3
  c define: USE_STDPERIPH_DRIVER,GD32H75E,PWM_FREQUENCY_HZ=20000UL,PWM_DUTY_PERMILLE=250UL,PWM_DEADTIME_NS=700UL,PWM_PROFILE_ID=5UL
  c misc: -ffunction-sections -fdata-sections
  c include: as above
  library: MicroLIB
  link misc: --remove
target 20k_75_700ns (6180000::V6.18::ARMCLANG)
  device: GD32H75EYMJ6 GigaDevice
  pack: GigaDevice.GD32H75E_DFP.1.4.0
  cpu: as above
  output: hil_pwm_20k_75_700ns +hex
  c flags: Optim=2 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=3
  c define: USE_STDPERIPH_DRIVER,GD32H75E,PWM_FREQUENCY_HZ=20000UL,PWM_DUTY_PERMILLE=750UL,PWM_DEADTIME_NS=700UL,PWM_PROFILE_ID=6UL
  c misc: -ffunction-sections -fdata-sections
  c include: as above
  library: MicroLIB
  link misc: --remove
target 20k_95_700ns (6180000::V6.18::ARMCLANG)
  device: GD32H75EYMJ6 GigaDevice
  pack: GigaDevice.GD32H75E_DFP.1.4.0
  cpu: as above
  output: hil_pwm_20k_95_700ns +hex
  c flags: Optim=2 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=3
  c define: USE_STDPERIPH_DRIVER,GD32H75E,PWM_FREQUENCY_HZ=20000UL,PWM_DUTY_PERMILLE=950UL,PWM_DEADTIME_NS=700UL,PWM_PROFILE_ID=7UL
  c misc: -ffunction-sections -fdata-sections
  c include: as above
  library: MicroLIB
  link misc: --remove
